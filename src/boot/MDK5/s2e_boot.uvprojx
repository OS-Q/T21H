# Keil uVision project s2e_boot.uvprojx, settings and files
target debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: s2e_boot +hex
  AfterMake: fromelf.exe #L --vhx --8x1 --output main.hex;fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\System;..\STM32XX_Driver\src;..\STM32XX_Driver\inc;..\output;..\Internet\w5500;..\Internet\Application;..\MDK5
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h usart.c usart.h config.h types.h spi.c spi.h
  group system
    ../System/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group stm32_driver
    ../STM32XX_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_iwdg.c
  group W5500
    ../Internet/w5500/: w5500.c w5500.h socket.c socket.h
  group Application
    ../Internet/Application/: mcu_init.c mcu_init.h device.c device.h 24c16.c 24c16.h iap.c iap.h util.c util.h
software components: CMSIS:CORE 5.3.0
