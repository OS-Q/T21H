# Keil uVision project s2e_app.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: fromelf.exe #L --vhx --8x1 --output main.hex;fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\System;..\STM32XX_Driver\src;..\STM32XX_Driver\inc;..\output;..\Internet\w5500;..\Internet\Application;..\Internet\AT_Commend
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h usart.c usart.h config.h types.h tsensor.c tsensor.h spi.c spi.h
  group system
    ../System/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group stm32_driver
    ../STM32XX_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_dma.c
  group W5500
    ../Internet/w5500/: socket.c socket.h w5500.c w5500.h
  group Application
    ../Internet/Application/: mcu_init.c mcu_init.h 24c16.c 24c16.h device.c device.h iap.c iap.h util.c util.h version.c
software components: CMSIS:CORE 5.3.0
